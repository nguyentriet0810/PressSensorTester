# Keil uVision project vcu.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: vcu +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\device;.\lib_os;.\lib_button;.\lib_com;.\lib_sdcard;.\lib_tft;.\lib_timer
  asm include: .\device;.\lib_button;.\lib_com;.\lib_os;.\lib_sdcard;.\lib_tft;.\lib_timer
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group OS
    ./lib_os/: os.c os.h os.s
  group Device
    ./device/: main.c main.h
  group tft
    ./lib_tft/: fonts.c fonts.h spi1.c spi1.h tft.c tft.h touch.c touch.h
  group com
    ./lib_com/: com.c com.h
  group button
    ./lib_button/: button.c button.h
  group timer
    ./lib_timer/: timer.c timer.h
  group sdcard
    ./lib_sdcard/: spi2.c spi2.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.6.0, Device:StdPeriph Drivers:Flash 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:I2C 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:SPI 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
