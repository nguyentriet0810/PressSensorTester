# Keil uVision project testchip.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: testchip
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\test_f4;.\Listings
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Device
    ./: main.c
  group Std_Driver
    ./CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h system_stm32f4xx.h
    ./CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ./CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f401xx.s
    ./STM32F4xx_StdPeriph_Driver/inc/: stm32f4xx_gpio.h stm32f4xx_rcc.h
