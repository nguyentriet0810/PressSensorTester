# Keil uVision project mcu.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: mcu +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\device;.\lib_ads1115;.\lib_com;.\lib_os;.\lib_timer;.\lib_hx711;.\lib_step_driver;.\lib_vl6180x
  asm include: .\device;.\lib_ads1115;.\lib_com;.\lib_hx711;.\lib_os;.\lib_step_driver;.\lib_timer;.\lib_vl6180x
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Os
    ./lib_os/: os.c os.h os.s
  group Device
    ./device/: main.c main.h
  group Hx711
    ./lib_hx711/: hx711.c hx711.h
  group Ads1115
    ./lib_ads1115/: adc.c adc.h iic.c iic.h
  group Step_Driver
    ./lib_step_driver/: step_driver.c step_driver.h
  group Com
    ./lib_com/: com.c com.h
  group Timer
    ./lib_timer/: timer.c timer.h
  group vl6180x
    ./lib_vl6180x/: vl6180x.c vl6180x.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.6.0, Device:StdPeriph Drivers:Flash 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:I2C 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
